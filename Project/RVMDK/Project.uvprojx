# Keil uVision project Project.uvprojx, settings and files
target 神舟IV号 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f107_lan
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL, USE_STM3210C_EVAL,SERVER
  c misc: --diag_suppress 236
  c include: ..\inc;..\..\Utilities\STM32_EVAL;..\..\Utilities\STM32_EVAL\STM3210C_EVAL;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\STM32_ETH_Driver\inc;..\..\Libraries\CMSIS\Core\CM3;..\..\Utilities\lwip-1.3.1\port\;..\..\Utilities\lwip-1.3.1\src\include;..\..\Utilities\lwip-1.3.1\src\include\ipv4;..\..\Utilities\lwip-1.3.1\src\include\lwip;..\..\Utilities\efsl\include;..\..\Utilities\efsl\include\interface
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../src/: stm32f10x_it.c main.c stm32f107.c netconf.c ARMJISHU_TouchScreen.c i2c_ee.c usart.c broadlink.c uart_printf.c
    ../../Utilities/lwip-1.3.1/port/: helloworld.c httpd.c tftpserver.c tftputils.c client.c server.c helloarmjishu.c
  group STM32F10x_StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_flash.c misc.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_i2c.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_dma.c
  group STM32_ETH_Driver
    ../../Libraries/STM32_ETH_Driver/src/: stm32_eth.c
  group STM32_EVAL
    ../../Utilities/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval_ioe.c stm3210c_eval_lcd.c
    ../../Utilities/STM32_EVAL/: stm32_eval.c
  group LwIP
    ../../Utilities/lwip-1.3.1/port/: ethernetif.c
    ../../Utilities/lwip-1.3.1/src/api/: tcpip.c api_lib.c netbuf.c netifapi.c netdb.c api_msg.c err.c
    ../../Utilities/lwip-1.3.1/src/core/: stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c dhcp.c init.c mem.c memp.c netif.c pbuf.c raw.c
    ../../Utilities/lwip-1.3.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../Utilities/lwip-1.3.1/src/netif/: etharp.c
  group efsl
    ../../Utilities/efsl/source/: dir.c disc.c efs.c extract.c fat.c file.c fs.c ioman.c ls.c mkfs.c partition.c plibc.c time.c ui.c
    ../../Utilities/efsl/source/interface/: sd.c sd_stm32.c
  group CMSIS
    ../../Libraries/CMSIS/Core/CM3/: system_stm32f10x.c core_cm3.c
  group RVMDK
    ../../Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_cl.s
